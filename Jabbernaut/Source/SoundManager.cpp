///--------------------------------------------------------------------------------------
//	File:		SoundManager.cpp
//	Project:	Jabbernaut
//
//	Purpose:	<default>
//	Created:	Wednesday, 2000-05-17
//	Authors:	MH - Max Horn <max@quendi.de>
//
//	Copyright:	(c) 2000-2001 Max Horn <max@quendi.de>
//
//	This program is free software; you can redistribute it and/or modify
//	it under the terms of the GNU General Public License as published by
//	the Free Software Foundation; either version 2 of the License, or
//	(at your option) any later version.
//	
//	This program is distributed in the hope that it will be useful,
//	but WITHOUT ANY WARRANTY; without even the implied warranty of
//	MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
//	GNU General Public License for more details.
//	
//	You should have received a copy of the GNU General Public License
//	along with this program; if not, write to the Free Software
//	Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA, or visit
//	<http://www.gnu.org/copyleft/gpl.html> on the World Wide Web.
///--------------------------------------------------------------------------------------


///- Includes ---------------------------------------------------------------------------
#pragma mark === Includes ===

#include	"SoundManager.h"

#include	"MacZoop.h"
#include	"ZSoundPlayer.h"


///- Static Members ---------------------------------------------------------------------
#pragma mark -
#pragma mark === Static Members ===

ZSoundPlayer*	SoundManager::msSoundPlayer = NULL;
bool			SoundManager::msSoundOn = true;


#pragma mark -


///--------------------------------------------------------------------------------------
//	Init:
//		Give this manager a chance to initate static members etc.
//		
//	Changes:
//		2000-05-18	MH		Created
///--------------------------------------------------------------------------------------
void	SoundManager::Init()
{
	ASSERT("msSoundPlayer != NULL",msSoundPlayer == NULL,0);
	//FailNIL( msSoundPlayer = new ZSoundPlayer() );
	msSoundPlayer=new ZSoundPlayer();
}


///--------------------------------------------------------------------------------------
//	Deinit:
//		Give this manager a chance to dispose static members etc.
//		
//	Changes:
//		2000-05-18	MH		Created
///--------------------------------------------------------------------------------------
void	SoundManager::Deinit()
{
	if( msSoundPlayer )
		ForgetObject( msSoundPlayer );
}


#pragma mark -


///--------------------------------------------------------------------------------------
//	Idle:
//		put your description here
//		
//	Changes:
//		2000-05-18	MH		Created
///--------------------------------------------------------------------------------------
void	SoundManager::Idle()
{
	if( msSoundPlayer )
		msSoundPlayer->Idle();
}


///--------------------------------------------------------------------------------------
//	Play:
//		put your description here
//		
//	Changes:
//		2000-05-18	MH		Created
///--------------------------------------------------------------------------------------
void	SoundManager::Play( short resID )
{
	if( msSoundOn && msSoundPlayer )
		msSoundPlayer->PlaySound( resID );
}


///--------------------------------------------------------------------------------------
//	Enable:
//		put your description here
//		
//	Changes:
//		2000-05-18	MH		Created
///--------------------------------------------------------------------------------------
void	SoundManager::Enable( bool soundOn )
{
	if( msSoundOn != soundOn )
	{
		msSoundOn = soundOn;
		if( !msSoundOn && msSoundPlayer )
			msSoundPlayer->MuteAll();
	}
}
