/*************************************************************************************************
*
*
*			MacZoop - "the framework for the rest of us"		 
*
*
*
*			ZErrors.cpp			-- utils for throwing exceptions
*
*
*
*
*
*			© 1996, Graham Cox
*
*
*
*
*************************************************************************************************/


#include	"ZErrors.h"
#include	"MacZoop.h"

#include	<Errors.h>
#include	<Resources.h>

/*----------------------------------***  FailNIL  ***-----------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception if argument is NULL
ins: 			<aPtr> pointer to check
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailNIL( void* aPtr )
{
	if ( aPtr == NULL )
		throw (ZoopError) memFullErr;
}


/*---------------------------------***  FailOSErr  ***----------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception if argument is non-zero
ins: 			<theErr> error code to throw (noErr = 0, is not thrown)
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailOSErr( OSErr theErr )
{
	if ( theErr != noErr )
		throw (ZoopError) theErr;
}


/*--------------------------------***  FailOSStatus  ***--------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception if argument is non-zero
ins: 			<theErr> error status code to throw (noErr = 0, is not thrown)
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void    FailOSStatus( OSStatus theErr )
{
	if ( theErr != noErr )
		throw (ZoopError) theErr;
}


/*--------------------------------***  FailMemError  ***--------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception if MemError toolbox status function returns non-zero
ins: 			none
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailMemError()
{
	FailOSErr( MemError());
}


/*--------------------------------***  FailResError  ***--------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception if ResError toolbox status function returns non-zero
ins: 			none
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailResError()
{
	FailOSErr( ResError());
}


/*------------------------------------***  Fail  ***------------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception regardless - error code is 999
ins: 			none
outs: 			none
notes:			only use if nothing else is more suitable
----------------------------------------------------------------------------------------*/

void	Fail()
{
	FailOSErr( kUnknownExceptionErr );
}


/*---------------------------------***  FailNILRes  ***---------------------------------*/
/*
access:			global
overrides:		
description: 	throw -192 exception if pointer is NULL
ins: 			<aResPtr> pointer to check - usually will be a resource handle
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailNILRes( void* aResPtr )
{
	if ( aResPtr == NULL )
		FailOSErr( resNotFound );
}


/*---------------------------------***  FailSilent  ***---------------------------------*/
/*
access:			global
overrides:		
description: 	always throw exception, but do not display error report to user
ins: 			none
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailSilent()
{
	FailOSErr( kSilentErr );
}


/*--------------------------------***  FailParamErr  ***--------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception if argument non-zero, but report as 951 error
ins: 			<theErr> error code to check
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailParamErr( OSErr theErr )
{
	if ( theErr != noErr )
		FailOSErr( kMacZoopParamErr1 );
}



/*--------------------------------***  FailNILParam  ***--------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception if argument is NULL, but report as 950 error
ins: 			<aPtr> pointer value to check
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailNILParam( void* aPtr )
{
	if ( aPtr == NULL )
		FailOSErr( kMacZoopParamErr );
}


/*---------------------------------***  FailNILErr  ***---------------------------------*/
/*
access:			global
overrides:		
description: 	throw exception if pointer argument is NULL, but report as supplied error
ins: 			<aPtr> pointer value to check
				<err> error code to throw if pointer is NULL
outs: 			none
notes:			
----------------------------------------------------------------------------------------*/

void	FailNILErr( void* aPtr, OSErr err )
{
	if ( aPtr == NULL )
	{
		if ( err == noErr )
			throw kUnknownExceptionErr;
		else
			throw (ZoopError) err;
	}
}